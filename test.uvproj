# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Application
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51
  group User
    ./User/: main.c gpio.c tim.c usart.c clock.c
  group Application
    ./Application/: key.c modbus.c numled.c
